options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Radio_Presidio_Prototype
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: PI
  id: variable
  parameters:
    value: '3.1415926'
  states: {state: disabled}
- name: afscratchvolume
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2:7,1,1,1
    label: Audio Scratch Volume
    min_len: '10'
    start: '0'
    step: '.1'
    stop: '10'
    value: '1'
    widget: slider
  states: {}
- name: ampl
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:1,3,1,1
    label: Tri-Tone Amplitude
    type: real
    value: 0 if not tritoneswitch else 1
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:1,3,1,1
    label: Heterodyne Amplitude Output
    min_len: '10'
    start: '0'
    step: '.01'
    stop: '1'
    value: '1'
  states: {}
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {state: disabled}
- name: atscrx
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:3,0,1,3
    label: RX ATSC
    'true': '1'
    type: int
    value: '0'
  states: {state: disabled}
- name: audio_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: audiofftmagnification
  id: variable_qtgui_range
  parameters:
    gui_hint: tab2@1
    label: Magnification
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: audiofftmagnification
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@5:0,1,1,1
    label: Audio FFT Magnification Factor
    min_len: '10'
    start: '1'
    step: '.1'
    stop: '100'
    value: '15'
    widget: slider
  states: {}
- name: audiofftmagnification
  id: variable
  parameters:
    value: '15'
  states: {state: disabled}
- name: cwkey
  id: variable_qtgui_push_button
  parameters:
    gui_hint: tab@1:4,1,1,1
    label: CW Key
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: finerxfirtune
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:3,2,1,3
    label: RX FIR Fine Tuning
    min_len: '10'
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: finetxfirtune
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:3,2,1,3
    label: TX FIR Fine Tuning
    min_len: '10'
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: firfiletxamplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:2,1,1,1
    label: TX FIR File Multiplier
    min_len: '10'
    start: '1'
    step: '10'
    stop: '1000'
    value: '100'
  states: {}
- name: firrate
  id: variable
  parameters:
    value: audio_rate * 4
  states: {}
- name: fm_deviation
  id: variable
  parameters:
    value: 4.5e3
  states: {state: disabled}
- name: freq_shift
  id: variable
  parameters:
    value: '-30e3'
  states: {state: disabled}
- name: integratedecimation
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@4
    label: Integration Decimation
    type: real
    value: '1'
  states: {state: disabled}
- name: label
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@0:0,3,1,2
    label: RX FIR Actual Frequency
    type: int
    value: rxfreq  + (rxoffset)
  states: {}
- name: lnagain
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:1,1,1,1
    label: ricgh
    type: int
    value: '0'
  states: {state: disabled}
- name: lnagain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:1,1,1,1
    label: BladeRF RX LNA Gain (dB)
    min_len: '10'
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {state: disabled}
- name: lnagain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:1,2,1,1
    label: BladeRF RX Gain (dB)
    min_len: '60'
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: micvolume
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2:0,2,1,1
    label: Microphone Input Volume
    min_len: '50'
    start: '0'
    step: '.01'
    stop: '20'
    value: '1'
    widget: slider
  states: {}
- name: mute
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:0,0,1,1
    label: Mute RX Audio during TX
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: muteaudioout
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:6,2,1,1
    label: Audio Mute
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: nbfmrxrate
  id: variable
  parameters:
    value: audio_rate * 2
  states: {}
- name: nbfmtxrate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: noisevolume
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:6,3,3,1
    label: Noise Volume
    type: real
    value: '.3'
  states: {state: disabled}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {state: disabled}
- name: pltone
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:1,2,1,1
    label: PL Tone Signal (Hz)
    type: real
    value: '100'
  states: {state: disabled}
- name: pltone
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2:1,2,1,1
    label: PL Tone Frequency
    min_len: '10'
    start: '0'
    step: '1'
    stop: '500'
    value: '100'
  states: {}
- name: pltone_0
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:1,1,1,1
    label: PL Tone Signal Amplitude
    type: real
    value: 0 if not pltoneswitch else .2
  states: {}
- name: pltoneswitch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:1,0,1,1
    label: Generate PL Tone
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: protect
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@0:3,1,1,1
    label: Zero RX gains if TX
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: readafscratch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:7,3,1,1
    label: Read AF from File
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: rx
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@0:0,0,1,1
    label: RX
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: rxagcswitch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:5,0,1,1
    label: Enable RX Audio AGC
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: rxaudiohigh
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:3,2,1,1
    label: RX Audio Low Pass (Hz)
    type: real
    value: '10000'
  states: {}
- name: rxaudiolow
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:3,1,1,1
    label: RX Audio High Pass (Hz)
    type: real
    value: '100'
  states: {}
- name: rxaudioskirt
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:3,3,1,1
    label: RX Audio Filter Skirt (Hz)
    type: real
    value: '100'
  states: {}
- name: rxbandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:4,2,1,1
    label: BladeRF RX Bandwidth
    type: real
    value: '0'
  states: {}
- name: rxdata
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@3:0,0,1,1
    label: Enable RX Data Modulation
    'true': '1'
    type: raw
    value: '0'
  states: {}
- name: rxdatamodulation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@3:0,2,1,1
    label: RX Data Modulation
    label0: ATSC Television
    num_opts: '1'
    option0: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
  states: {}
- name: rxfilterswitch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:3,0,1,1
    label: Filter RX Audio
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: rxfirfile
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@0:4,0,1,1
    label: Read FIR File
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: rxfirfilterskirt
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@4:1,2,1,1
    label: RX FIR Filter Skirt
    min_len: '10'
    start: '1'
    step: '10'
    stop: '100000'
    value: '10000'
  states: {}
- name: rxfirswitch
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@0:3,0,1,1
    label: Write FIR File
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: rxfirtuning
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,2,1,1
    label: RX FIR Frequency Offset
    type: real
    value: '725000'
  states: {}
- name: rxfirwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,3,1,1
    label: RX FIR Window Width (Hz)
    type: real
    value: '20000'
  states: {state: disabled}
- name: rxfirwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@4:1,1,1,1
    label: RX FIR Filter Width
    min_len: '10'
    start: '0'
    step: '1000'
    stop: '300000'
    value: '10000'
  states: {}
- name: rxfreq
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,1,1,1
    label: BladeRF RX  Frequency
    type: real
    value: '438000000'
  states: {}
- name: rxiqswitch
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@0:4,4,1,1
    label: Save RX IQ Data to File
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: rxmodulation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@4:0,1,1,1
    label: RX Modulation
    label0: Narrow Band FM
    label1: Wide Band FM
    label2: Amplitude Modulation
    label3: Upper Side Band
    label4: Lower Side Band
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
  states: {}
- name: rxoffset
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:3,2,1,3
    label: RX FIR Fine Tuning
    min_len: '10'
    start: '-2500 + firtuning'
    step: '1'
    stop: 2500 + firtuning
    value: 0 + firtuning
  states: {state: disabled}
- name: rxoffset
  id: variable
  parameters:
    value: (finerxfirtune+rxfirtuning)
  states: {}
- name: rxoutputgain
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:5,1,1,1
    label: RX Output Gain
    type: real
    value: '50'
  states: {}
- name: rxsource
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@0:4,3,1,1
    label: RX Source
    label0: BladeRF USB Radio Card
    label1: IQ Sampled Data File
    label2: Null Source
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: rxtx
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:6,1,1,1
    label: Enable TX RXed Audio
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: rxvga1gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:1,2,1,1
    label: BladeRF RX VGA1 Gain (dB)
    min_len: '10'
    start: '-120'
    step: '1'
    stop: '120'
    value: '-120'
  states: {state: disabled}
- name: rxvga2gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:1,3,1,1
    label: BladeRF RXVGA2 Gain (dB)
    min_len: '10'
    start: '-120'
    step: '1'
    stop: '120'
    value: '-120'
  states: {state: disabled}
- name: rxvolume
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2:0,1,1,1
    label: RX Audio Output Volume
    min_len: '10'
    start: '0'
    step: '.01'
    stop: '5'
    value: '.5'
    widget: slider
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:4,1,1,1
    label: Flowgraph Sample Rate
    type: real
    value: '3840000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000 '
  states: {state: disabled}
- name: samp_rate_0
  id: variable
  parameters:
    value: '96000'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: 8e6
  states: {state: disabled}
- name: saveaudio
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@5:5,0,1,1
    label: Write WAV
    'true': 'True'
    type: int
    value: 'False'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: sps_0
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: sps_1
  id: variable
  parameters:
    value: '1.1'
  states: {state: disabled}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2:5,2,1,2
    label: RX Power Squelch (dBFS)
    min_len: '10'
    start: '-150'
    step: '1'
    stop: '0'
    value: '-75'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '2400'
  states: {state: disabled}
- name: toneone
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:2,1,1,1
    label: 'Tone One Frequency: (Hz)'
    type: real
    value: '783.99'
  states: {}
- name: tonethree
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:2,3,1,1
    label: 'Tone Three Frequency: (Hz)'
    type: real
    value: '1318.5'
  states: {}
- name: tonetwo
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:2,2,1,1
    label: 'Tone Two Frequency: (Hz)'
    type: real
    value: '1046.5'
  states: {}
- name: tritoneswitch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:2,0,1,1
    label: Generate Tri-Tone
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: tx
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@1:0,0,1,1
    label: TX
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: txagcswitch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:6,0,1,1
    label: Enable TX Audio AGC
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: txaudiohigh
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:4,2,1,1
    label: TX Audio Low Pass (Hz)
    type: real
    value: '10000'
  states: {}
- name: txaudiolow
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:4,1,1,1
    label: TX Audio High Pass (Hz)
    type: real
    value: '100'
  states: {}
- name: txaudioskirt
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:4,3,1,1
    label: TX Audio Filter Skirt (Hz)
    type: real
    value: '100'
  states: {}
- name: txbandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:4,2,1,1
    label: BladeRF TX Bandwidth
    type: real
    value: '0'
  states: {}
- name: txdata
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@3:1,0,1,1
    label: Enable TX Data Modulation
    'true': '1'
    type: raw
    value: '0'
  states: {}
- name: txdatamodulation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@3:1,2,1,1
    label: TX Data Modulation
    label0: ATSC Television
    num_opts: '1'
    option0: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
  states: {}
- name: txfiltergain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: txfilterswitch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:4,0,1,1
    label: Filter TX Audio
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: txfirdisplay
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@1:0,3,1,1
    label: TX FIR Actual Frequency
    type: int
    value: txfreq  + (txoffset)
  states: {}
- name: txfirfile
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab@1:2,2,1,1
    label: TX FIR File
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: txfirfilterskirt
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@4:3,2,1,1
    label: TX FIR Filter Skirt
    min_len: '10'
    start: '1000'
    step: '10'
    stop: '100000'
    value: '70000'
  states: {}
- name: txfirfilterskirt
  id: variable
  parameters:
    value: txfirfilterwidth/10
  states: {state: disabled}
- name: txfirfilterwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@4:3,1,1,1
    label: TX FIR Filter Width
    min_len: '10'
    start: '0'
    step: '1000'
    stop: '300000'
    value: '100000'
  states: {}
- name: txfirfilterwidth
  id: variable
  parameters:
    value: samp_rate // nbfmtxrate * 20000
  states: {state: disabled}
- name: txfirgain
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@3
    label: TX FIR Filter Gain
    type: real
    value: '1'
  states: {state: disabled}
- name: txfirtuning
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:0,2,1,1
    label: TX FIR Signal Offset
    type: real
    value: '725000'
  states: {}
- name: txfreq
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:0,1,1,1
    label: Blade RF TX Frequency
    type: int
    value: '438000000'
  states: {}
- name: txmodulation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@4:0,2,1,1
    label: TX Modulation
    label0: Narrow Band FM
    label1: Wide Band FM
    label2: Amplitude Modulation
    label3: Upper Side Band
    label4: Lower Side Band
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
  states: {}
- name: txoffset
  id: variable
  parameters:
    value: (finetxfirtune+txfirtuning)
  states: {}
- name: txoutputgain
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@3
    label: TX Output Gain
    type: real
    value: '1'
  states: {state: disabled}
- name: txsink
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@1:4,3,1,1
    label: TX Sink
    label0: BladeRF USB Radio Card
    label1: IQ Sampled Data File
    label2: Null Sink
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: raw
    value: '0'
  states: {}
- name: txvga1gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:1,1,1,1
    label: BladeRF TX VGA1 Gain (dB)
    min_len: '10'
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-35'
  states: {}
- name: txvga2gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:1,2,1,1
    label: BladeRF TX VGA2 Gain (dB)
    min_len: '10'
    start: '16'
    step: '1'
    stop: '73'
    value: '16'
  states: {}
- name: txwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:0,3,1,1
    label: TX FIR Window Width (Hz)
    type: real
    value: '10000'
  states: {state: disabled}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: real
    value: '0'
    writeback: None
  states: {state: disabled}
- name: wav_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: wavvolume
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2:0,3,1,1
    label: WAV Input Volume
    min_len: '10'
    start: '0'
    step: '.1'
    stop: '10'
    value: '0'
    widget: slider
  states: {}
- name: wbfmrxrate
  id: variable
  parameters:
    value: audio_rate * 4
  states: {}
- name: wbfmtxrate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: writeafscratch
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tab@2:6,3,1,1
    label: Write AF to File
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: Osmocom_RX
  id: osmosdr_source
  parameters:
    args: bladerf=0,buffers=128
    bb_gain0: '0'
    bw0: rxbandwidth
    freq0: rxfreq
    gain0: lnagain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: Osmocom_RX_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,verbosity=verbose,buffers=128
    bb_gain0: 0 if (tx and protect) else rxvga2gain
    bw0: rxbandwidth
    freq0: rxfreq
    gain0: 0 if (tx and protect) else lnagain
    gain_mode0: 'True'
    if_gain0: 5 if (tx and protect) else rxvga1gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: afscratchvolumeblock
  id: blocks_multiply_const_vxx
  parameters:
    const: afscratchvolume
    type: float
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '.1'
    decay_rate: '.1'
    gain: '1.0'
    max_gain: 1 if not txagcswitch else 65536
    reference: '1.0 '
    type: float
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '10'
    gain: '1'
    max_gain: 1 if not rxagcswitch else 65536
    reference: '.8'
    type: float
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '0.00001'
    gain: '1.0'
    max_gain: '5'
    reference: '3.0'
    type: complex
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '4'
    type: float
  states: {state: disabled}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '10000'
    audio_stop: '11000'
    chan_rate: '384000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: '10000'
    quad_rate: nbfmrxrate * 2
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: '20000'
    quad_rate: nbfmtxrate
    tau: '150e-6'
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: '60000'
    quad_rate: nbfmtxrate
    tau: '150e-6'
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_1_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.02'
    gate: 'False'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude if tx else 0
    freq: txoffset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: pltone_0
    freq: pltone
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: ampl
    freq: tonetwo
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2_0
  id: analog_sig_source_x
  parameters:
    amp: ampl
    freq: tonethree
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_4
  id: analog_sig_source_x
  parameters:
    amp: cwkey
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: ampl
    freq: toneone
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: wbfmrxrate // audio_rate
    quad_rate: 'wbfmrxrate '
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: '20000'
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: atscrxselector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    alias: '3'
    device_name: pulse
    ok_to_block: 'False'
    samp_rate: '96000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: audioinputadd
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: band_pass_filter
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '50'
    samp_rate: '96000'
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: txfiltergain
    high_cutoff_freq: '5000'
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: txfiltergain
    high_cutoff_freq: '-200'
    interp: '1'
    low_cutoff_freq: '-5000'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    gain: txfiltergain
    high_cutoff_freq: '10000'
    interp: '1'
    low_cutoff_freq: '-10000'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-50'
    low_cutoff_freq: '-10000'
    samp_rate: audio_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blks2_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: txmodulation
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blks2_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '5'
    output_index: txmodulation
    type: float
  states: {}
- name: blks2_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: rxmodulation
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blks2_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: txfirfile
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blks2_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: tx
    type: float
  states: {}
- name: blks2_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: rxfirfile
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blks2_selector_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: txdata
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blks2_selector_4
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: txdata
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"./radiodata/afscratch.raw" if writeafscratch else "/dev/null"'
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: os.path.expanduser("~")/radiodata/atscrx.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: '"./radiodata/rxiqfile.iq" if rxiqswitch else "/dev/null"'
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: ./radiodata/txiqfile.iq
    type: complex
  states: {}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: '"./radiodata/rxfirfile.iq" if rxfirswitch else "/dev/null"'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./radiodata/rxiqfile.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: ./radiodata/rxfirfile.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: '"./radiodata/afscratch.raw" if readafscratch else "/dev/zero"'
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: '"./radiodata/rxfirfile.iq" if rxfirfile else "/dev/zero"'
    maxoutbuf: '1000'
    minoutbuf: '100'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: audiofftmagnification * 10
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: wavvolume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0 if (tx and mute) else rxvolume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: micvolume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: firfiletxamplitude
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rxoutputgain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: rxoutputgain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rxoutputgain
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_3_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: firrate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    append: 'True'
    bits_per_sample1: FORMAT_PCM_16
    file: ./radiodata/rx.wav
    format: FORMAT_WAV
    samp_rate: '96000'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: ./radiodata/doorbell2.wav
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dtv_atsc_deinterleaver_0
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {state: disabled}
- name: dtv_atsc_depad_0
  id: dtv_atsc_depad
  parameters: {}
  states: {state: disabled}
- name: dtv_atsc_derandomizer_0
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {state: disabled}
- name: dtv_atsc_equalizer_0
  id: dtv_atsc_equalizer
  parameters: {}
  states: {state: disabled}
- name: dtv_atsc_fpll_0
  id: dtv_atsc_fpll
  parameters:
    rate: oversampled_rate
  states: {state: disabled}
- name: dtv_atsc_fs_checker_0
  id: dtv_atsc_fs_checker
  parameters: {}
  states: {state: disabled}
- name: dtv_atsc_rs_decoder_0
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {state: disabled}
- name: dtv_atsc_rx_filter_1
  id: dtv_atsc_rx_filter
  parameters:
    rate: samp_rate
    sps: sps
  states: {state: disabled}
- name: dtv_atsc_sync_0
  id: dtv_atsc_sync
  parameters:
    rate: oversampled_rate
  states: {state: disabled}
- name: dtv_atsc_viterbi_decoder_0
  id: dtv_atsc_viterbi_decoder
  parameters: {}
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rxoffset
    decim: samp_rate // firrate
    maxoutbuf: '10000'
    minoutbuf: '2000'
    samp_rate: samp_rate
    taps: firdes.low_pass_2(1, samp_rate, rxfirwidth, rxfirfilterskirt, 40, window.win_type.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: firdes.low_pass_2(1, samp_rate, txfirfilterwidth, txfirfilterskirt, 40, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: CPU Saver
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: USB TX
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: LSB TX
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: AM TX
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: Heterodyne Generators
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: Audio TX Output
  states: {}
- name: note_0_1_0_0_0
  id: note
  parameters:
    note: RX Input
  states: {}
- name: note_0_1_0_0_0_0
  id: note
  parameters:
    note: USB RX
  states: {}
- name: note_0_1_0_0_0_0_0
  id: note
  parameters:
    note: LSB RX
  states: {}
- name: note_0_1_0_0_0_1
  id: note
  parameters:
    note: AM RX
  states: {state: disabled}
- name: note_0_1_0_0_0_10
  id: note
  parameters:
    note: RX Output
  states: {}
- name: note_0_1_0_0_0_10_0
  id: note
  parameters:
    note: RX Volume
  states: {}
- name: note_0_1_0_0_0_3
  id: note
  parameters:
    note: RX Offset Filters
  states: {}
- name: note_0_1_0_0_0_5
  id: note
  parameters:
    note: WBFM RX
  states: {}
- name: note_0_1_0_0_0_6
  id: note
  parameters:
    note: NBFM RX
  states: {}
- name: note_0_1_1
  id: note
  parameters:
    note: Modulation Filters
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: WBFM TX
  states: {}
- name: note_0_3
  id: note
  parameters:
    note: NBFM TX
  states: {}
- name: note_0_4
  id: note
  parameters:
    note: 'S/N Test Generator '
  states: {}
- name: note_0_5
  id: note
  parameters:
    note: Input Volume
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0,buffers=128
    bb_gain0: txvga1gain if tx else -35
    bw0: txbandwidth
    freq0: txfreq
    gain0: txvga2gain if tx else 0
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_fosphor_display_0
  id: qtgui_fosphor_display
  parameters:
    center_freq: '0.0'
    fftsize: '256'
    frame_rate: '10'
    grid_enabled: 'True'
    gui_hint: tab2@0
    palette: iron
    pwr_bins: '64'
    samp_rate: samp_rate
    wf_enabled: 'True'
    wf_lines: '512'
  states: {state: disabled}
- name: qtgui_fosphor_formatter_0
  id: qtgui_fosphor_formatter
  parameters:
    alpha: '0.9'
    epsilon: '0.9'
    fft_size: '256'
    histo_decim: '64'
    input_decim: '1'
    num_bins: '64'
    scale: '1.0'
    tdecay: '1024.0'
    trise: '16.0'
    wf_decim: '16'
  states: {state: disabled}
- name: qtgui_fosphorgl_sink_0
  id: qtgui_fosphorgl_sink
  parameters:
    alias: '6'
    alpha: '0.1'
    center_freq: '0.0'
    epsilon: '0.99'
    frame_rate: '1'
    grid_enabled: 'True'
    gui_hint: tab2@0
    histo_decim: '64'
    input_decim: '1'
    palette: iron
    samp_rate: samp_rate
    scale: '1.0'
    tdecay: '1024.0'
    trise: '16.0'
    wf_decim: '4'
    wf_lines: '512'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '10000'
    grid: 'True'
    gui_hint: 0,2,1,1
    name: TX RF Output FFT
    showports: 'True'
    type: complex
    update_time: '0.01'
    ymax: '1'
    ymin: '-190'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024 * 2
    grid: 'True'
    gui_hint: tab2@2
    type: complex
    update_time: '0.01'
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rxfirwidth
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    gui_hint: tab2@3
    showports: 'True'
    type: complex
    update_time: '0.01'
    ymax: '0'
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: tab@0:1,0,1,1
    label: '"RX active"'
    state: rx
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: ''
    name: TX Audio Input Scope
    size: 4096 * 2
    srate: audio_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: ''
    name: RX Audio Output Scope
    size: 4096 * 2
    srate: audio_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    gui_hint: tab2@0
    int_max: '-50'
    int_min: '-110'
    name: RX Waterfall
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rxfirwidth
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    gui_hint: tab2@4
    int_max: '-20'
    name: FIR Waterfall
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate / audiofftmagnification * 10
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    gui_hint: tab2@1
    showports: 'True'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate / audiofftmagnification
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    gui_hint: tab2@5
    int_max: '0'
    int_min: '-90'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    gui_hint: 0,2,1,1
    name: TX IQ Input Waterfall
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // firrate *2
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // firrate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // nbfmtxrate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: audiofftmagnification
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: 'samp_rate // audio_rate '
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rx_audio_band_pass_filter
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: rxaudiohigh
    interp: '1'
    low_cutoff_freq: rxaudiolow
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: rxaudioskirt
    win: window.WIN_RECTANGULAR
  states: {}
- name: rx_selector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '5'
    output_index: rxmodulation
    type: complex
  states: {}
- name: rxaudiofilterselector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: rxfilterswitch
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: rxsourceselector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: rxsource
    num_inputs: '3'
    num_outputs: '2'
    output_index: rx
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: txfreq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: '432000000'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: RX
    label1: TX
    label2: Audio
    label3: Data
    label4: Modulation
    label5: Instrumentation
    num_tabs: '6'
  states: {}
- name: tab2
  id: qtgui_tab_widget
  parameters:
    label0: Waterfall
    label1: Audio FFT
    label2: IQ FFT
    label3: FIR FFT
    label4: FIR Waterfall
    label5: Decimation FFT
    num_tabs: '6'
  states: {}
- name: tx_audio_band_pass_filter
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: txaudiohigh
    interp: '1'
    low_cutoff_freq: txaudiolow
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: txaudioskirt
    win: window.WIN_HAMMING
  states: {}
- name: txfilterselector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: txfilterswitch
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: txsinkselector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: txsink
    type: complex
  states: {}

connections:
- [Osmocom_RX, '0', rxsourceselector, '0']
- [afscratchvolumeblock, '0', blocks_add_xx_1, '1']
- [analog_agc2_xx_0, '0', blocks_add_xx_0, '0']
- [analog_agc2_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_agc2_xx_1, '0', analog_am_demod_cf_0, '0']
- [analog_agc_xx_0, '0', dtv_atsc_sync_0, '0']
- [analog_am_demod_cf_0, '0', blks2_selector_0_0_0, '2']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_nbfm_rx_0, '0', blks2_selector_0_0_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0_2_0, '0']
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_0_1_0, '0']
- [analog_pwr_squelch_xx_0_0_1_0_0, '0', rx_selector, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_2, '0', blocks_add_xx_0, '4']
- [analog_sig_source_x_0_2_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_4, '0', blocks_add_xx_0, '5']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '3']
- [analog_wfm_rcv_0, '0', blks2_selector_0_0_0, '1']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_1_0, '0']
- [atscrxselector, '0', blocks_null_sink_2, '0']
- [atscrxselector, '1', blocks_null_sink_2_0, '0']
- [atscrxselector, '1', dtv_atsc_rx_filter_1, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [audioinputadd, '0', tx_audio_band_pass_filter, '0']
- [audioinputadd, '0', txfilterselector, '0']
- [band_pass_filter, '0', blocks_multiply_const_vxx_1_0_0_0_3, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_2_0_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_2_0_0_0, '0']
- [band_pass_filter_0_1, '0', rational_resampler_xxx_2, '0']
- [band_pass_filter_0_2, '0', blocks_multiply_const_vxx_1_0, '0']
- [blks2_selector_0, '0', blks2_selector_1, '0']
- [blks2_selector_0_0, '0', analog_nbfm_tx_0, '0']
- [blks2_selector_0_0, '1', analog_nbfm_tx_0_0, '0']
- [blks2_selector_0_0, '1', analog_wfm_tx_0, '0']
- [blks2_selector_0_0, '2', blocks_float_to_complex_0, '0']
- [blks2_selector_0_0, '3', blocks_float_to_complex_0_0, '0']
- [blks2_selector_0_0, '4', blocks_float_to_complex_0_0_0, '0']
- [blks2_selector_0_0_0, '0', analog_agc2_xx_0_0, '0']
- [blks2_selector_1, '0', interp_fir_filter_xxx_0_1, '0']
- [blks2_selector_1_0, '0', blocks_null_sink_1_0, '0']
- [blks2_selector_1_0, '1', blks2_selector_0_0, '0']
- [blks2_selector_1_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [blks2_selector_2, '0', analog_pwr_squelch_xx_0_0_1_0_0, '0']
- [blks2_selector_2, '0', atscrxselector, '0']
- [blks2_selector_2, '0', qtgui_freq_sink_x_1_0, '0']
- [blks2_selector_2, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blks2_selector_3, '0', qtgui_freq_sink_x_0_0, '0']
- [blks2_selector_3, '0', qtgui_waterfall_sink_x_2, '0']
- [blks2_selector_3, '0', txsinkselector, '0']
- [blks2_selector_4, '1', blocks_null_sink_0, '0']
- [blocks_add_xx_0, '0', blks2_selector_1_0, '0']
- [blocks_add_xx_1, '0', audioinputadd, '0']
- [blocks_complex_to_real_0, '0', blks2_selector_0_0_0, '3']
- [blocks_complex_to_real_0_0, '0', blks2_selector_0_0_0, '4']
- [blocks_copy_0, '0', blks2_selector_2, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_file_source_1, '0', afscratchvolumeblock, '0']
- [blocks_file_source_1_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_1, '0']
- [blocks_float_to_complex_0_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', audioinputadd, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', rx_audio_band_pass_filter, '0']
- [blocks_multiply_const_vxx_0_0, '0', rxaudiofilterselector_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_0_1_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0_0_3, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_1_0_0_0_3_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_xx_0, '0', blks2_selector_3, '0']
- [blocks_null_source_0, '0', blks2_selector_4, '0']
- [blocks_null_source_0_0, '0', blks2_selector_3, '1']
- [blocks_null_source_1, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', rxsourceselector, '1']
- [blocks_throttle_0_0, '0', rxsourceselector, '2']
- [blocks_throttle_0_0_0, '0', blocks_copy_0, '0']
- [blocks_throttle_1, '0', blocks_file_sink_1_0, '0']
- [blocks_throttle_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dtv_atsc_deinterleaver_0, '0', dtv_atsc_rs_decoder_0, '0']
- [dtv_atsc_deinterleaver_0, '1', dtv_atsc_viterbi_decoder_0, '1']
- [dtv_atsc_depad_0, '0', blocks_file_sink_0_0, '0']
- [dtv_atsc_derandomizer_0, '0', dtv_atsc_depad_0, '0']
- [dtv_atsc_equalizer_0, '0', dtv_atsc_viterbi_decoder_0, '0']
- [dtv_atsc_equalizer_0, '1', dtv_atsc_derandomizer_0, '1']
- [dtv_atsc_fpll_0, '0', dc_blocker_xx_0, '0']
- [dtv_atsc_fs_checker_0, '0', dtv_atsc_equalizer_0, '0']
- [dtv_atsc_fs_checker_0, '1', dtv_atsc_equalizer_0, '1']
- [dtv_atsc_fs_checker_0, '1', dtv_atsc_rs_decoder_0, '1']
- [dtv_atsc_rs_decoder_0, '0', dtv_atsc_derandomizer_0, '0']
- [dtv_atsc_rs_decoder_0, '1', dtv_atsc_deinterleaver_0, '1']
- [dtv_atsc_rx_filter_1, '0', dtv_atsc_fpll_0, '0']
- [dtv_atsc_sync_0, '0', dtv_atsc_fs_checker_0, '0']
- [dtv_atsc_viterbi_decoder_0, '0', dtv_atsc_deinterleaver_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blks2_selector_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_1_0_1, '0']
- [interp_fir_filter_xxx_0_1, '0', blocks_multiply_xx_0, '1']
- [qtgui_fosphor_formatter_0, '0', qtgui_fosphor_display_0, '0']
- [qtgui_fosphor_formatter_0, '1', qtgui_fosphor_display_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_1_0, '0', blks2_selector_0, '1']
- [rational_resampler_xxx_0_1_0_0, '0', blks2_selector_1, '1']
- [rational_resampler_xxx_0_2_0, '0', blks2_selector_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_2, '0', blks2_selector_0, '2']
- [rational_resampler_xxx_2_0_0, '0', blks2_selector_0, '3']
- [rational_resampler_xxx_2_0_0_0, '0', blks2_selector_0, '4']
- [rational_resampler_xxx_3, '0', band_pass_filter, '0']
- [rational_resampler_xxx_3_0, '0', band_pass_filter_0_2, '0']
- [rx_audio_band_pass_filter, '0', rxaudiofilterselector_0, '1']
- [rx_selector, '0', analog_nbfm_rx_0, '0']
- [rx_selector, '1', analog_wfm_rcv_0, '0']
- [rx_selector, '2', blocks_multiply_const_vxx_1_0_0_0_3_0, '0']
- [rx_selector, '3', rational_resampler_xxx_3, '0']
- [rx_selector, '4', rational_resampler_xxx_3_0, '0']
- [rxaudiofilterselector_0, '0', audio_sink_0, '0']
- [rxaudiofilterselector_0, '0', blocks_file_sink_0, '0']
- [rxaudiofilterselector_0, '0', blocks_wavfile_sink_0, '0']
- [rxaudiofilterselector_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [rxsourceselector, '0', blocks_null_sink_1, '0']
- [rxsourceselector, '1', blocks_throttle_1, '0']
- [rxsourceselector, '1', qtgui_fosphor_formatter_0, '0']
- [rxsourceselector, '1', qtgui_fosphorgl_sink_0, '0']
- [soapy_bladerf_source_0, '0', rxsourceselector, '0']
- [tx_audio_band_pass_filter, '0', txfilterselector, '1']
- [txfilterselector, '0', analog_agc2_xx_0, '0']
- [txsinkselector, '0', osmosdr_sink_0, '0']
- [txsinkselector, '0', soapy_bladerf_sink_0, '0']
- [txsinkselector, '1', blocks_file_sink_1_0_0, '0']
- [txsinkselector, '2', blocks_null_sink_1_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
